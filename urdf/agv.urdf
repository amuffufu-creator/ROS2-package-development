Commit message: add simulating files

File: urdf/agv.urdf (robot description, URDF)
Before this commit: robot agv_3wheel, 4 links, 3 joints
Joints:
- joint lidar_joint: origin xyz=0.23 -0.01 0.22 rpy=0 0 0 -> xyz=0.085 -0.01 0.175 rpy=0 0 0
